# Keil uVision project Ambition_hero_G.uvprojx, settings and files
target FreeRTOS (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,Ambition_2021
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CORE;..\DSP\Include;..\BSP\adc;..\BSP\buzzer;..\BSP\can;..\BSP\exit_init;..\BSP\flash;..\BSP\fric;..\BSP\laser;..\BSP\led;..\BSP\power_ctrl;..\BSP\rc;..\BSP\rng;..\BSP\spi;..\BSP\timer;..\TASK\start_task;..\TASK;..\TASK\led_task;..\TASK\ins_task;..\FUNC\PID;..\FUNC\user_lib;..\FUNC\AHRS;..\FUNC\Remote_control;..\FUNC\MOTOR;..\TASK\chassis_task;..\FUNC\CAN;..\TASK\gimbal_task;..\FUNC\exchange;..\BSP\usart;..\TASK\shoot_task;..\FUNC\visual_recognition;..\BSP\oled;..\FUNC\fpv_control;..\FUNC\kalman
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c Ambition_data_rule.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ../CORE/: startup_stm32f427xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group APP_TASK
    ../TASK/start_task/: start_task.c
    ../TASK/led_task/: led_task.c
    ../TASK/ins_task/: INS_task.c
    ../TASK/chassis_task/: chassis_task.c
    ../TASK/gimbal_task/: gimbal_task.c
    ../TASK/shoot_task/: shoot_task.c
  group BSP
    ../BSP/adc/: adc.c
    ../BSP/buzzer/: buzzer.c
    ../BSP/can/: can.c
    ../BSP/exit_init/: exit_init.c
    ../BSP/flash/: flash.c
    ../BSP/laser/: laser.c
    ../BSP/led/: led.c
    ../BSP/power_ctrl/: power_ctrl.c
    ../BSP/rc/: rc.c
    ../BSP/rng/: rng.c
    ../BSP/spi/: spi.c
    ../BSP/timer/: timer.c
    ../BSP/usart/: usart.c
    ../BSP/oled/: oled.c
  group DSP
    ../DSP/: arm_cortexM4lf_math.lib
  group AHRS
    ../FUNC/AHRS/: AHRS_middleware.c ist8310driver.c ist8310driver_middleware.c mpu6500driver.c mpu6500driver_middleware.c AHRS.lib
  group PID
    ../FUNC/PID/: pid.c Ambition_pid.c
  group user_lib
    ../FUNC/user_lib/: user_lib.c
  group Remote_control
    ../FUNC/Remote_control/: remote_control.c
    ../FUNC/fpv_control/: fpv_control.c
  group MOTOR
    ../FUNC/MOTOR/: chassis_behaviour.c gimbal_behaviour.c snail_motor.c
  group CAN
    ../FUNC/CAN/: CAN_receive.c
  group Visual_recognition
    ../FUNC/visual_recognition/: visual_recognition.c
    ../FUNC/kalman/: kalman.c kalman_filter.c

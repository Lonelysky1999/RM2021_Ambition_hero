# Keil uVision project Ambition_hero_C.uvprojx, settings and files
target FreeRTOS (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,Ambition_2021
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CORE;..\DSP\Include;..\BSP\can;..\BSP\led;..\BSP\timer;..\TASK\start_task;..\TASK;..\TASK\led_task;..\FUNC\PID;..\FUNC\user_lib;..\TASK\chassis_task;..\FUNC\CAN;..\FUNC\exchange;..\BSP\usart;..\TASK\decision;..\BSP\power_ctrl;..\BSP\spi;..\BSP\oled;..\FUNC\ui;..\FUNC\CRC
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORE
    ../CORE/: startup_stm32f427xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group APP_TASK
    ../TASK/start_task/: start_task.c
    ../TASK/led_task/: led_task.c
    ../TASK/chassis_task/: chassis_task.c
    ../TASK/decision/: decision.c data_core.c
  group BSP
    ../BSP/can/: can.c
    ../BSP/led/: led.c
    ../BSP/timer/: timer.c
    ../BSP/usart/: usart.c
    ../BSP/power_ctrl/: power_ctrl.c
    ../BSP/oled/: oled.c
    ../BSP/spi/: spi.c
  group DSP
    ../DSP/: arm_cortexM4lf_math.lib
  group PID
    ../FUNC/PID/: pid.c Ambition_pid.c
  group user_lib
    ../FUNC/user_lib/: user_lib.c
  group UI
    ../FUNC/ui/: ui.c
    ../FUNC/CRC/: CRC8_CRC16.c
  group CAN
    ../FUNC/CAN/: CAN_receive.c
